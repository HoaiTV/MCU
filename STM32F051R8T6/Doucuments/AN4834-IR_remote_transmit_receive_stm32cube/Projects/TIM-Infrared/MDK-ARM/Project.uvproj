# Keil uVision project Project.uvproj, settings and files
target STM32373C_EVAL (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32373C_EVAL
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F373xC,USE_HAL_DRIVER,USE_STM32373C_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32373C_EVAL;..\..\..\Drivers\BSP\Components\Common;..\..\..\Utilities\Log;..\..\..\Utilities\CPU;
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../Drivers/BSP/Components/stlm75/: stlm75.c
  group Drivers/BSP/STM32072B_EVAL
    ../../../Drivers/BSP/STM32072B_EVAL/: stm32072b_eval.c stm32072b_eval_lcd.c
  group Drivers/BSP/STM32303C_EVAL
    ../../../Drivers/BSP/STM32303C_EVAL/: stm32303c_eval.c stm32303c_eval_lcd.c
  group Drivers/BSP/STM32373C_EVAL
    ../../../Drivers/BSP/STM32373C_EVAL/: stm32373c_eval.c stm32373c_eval_lcd.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s startup_stm32f303xc.s
  group Example/User
    ../Src/: ir_common.c main.c menu.c rc5_decode.c rc5_encode.c sirc_decode.c sirc_encode.c stm32f0xx_hal_msp.c stm32f0xx_it.c
target STM32303C_EVAL (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: as above
  output: STM32303C_EVAL
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,USE_STM32303C_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\Components\Common;..\..\..\Utilities\Log;..\..\..\Utilities\CPU;..\..\..\Drivers\BSP\STM32303C_EVAL;
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group added to the first target's files
    ./: startup_stm32f373xc.s
  group left out of the first target's files
    ./: startup_stm32f303xc.s
target STM32072B_EVAL (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32072B_EVAL
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32072B_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\Components\Common;..\..\..\Utilities\Log;..\..\..\Utilities\CPU;..\..\..\Drivers\BSP\STM32072B_EVAL;..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group added to the first target's files
    ../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../Drivers/BSP/Components/ili9328/: ili9328.c
    ../Src/: stm32f3xx_hal_msp.c stm32f3xx_it.c system_stm32f3xx.c
    ./: startup_stm32f373xc.s
  group left out of the first target's files
    ../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c
    ./: startup_stm32f072xb.s
