# IAR project Platform.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.PreInclude: types.h
  ICCARM.CCIncludePath2: Application\Main; Libraries\CMSIS\; Libraries\STM32F10x_StdPeriph_Driver\inc\; Libraries\Systemconfig\; Service\Timer; Service\Modbus; Service\Parameters; Service\Device; Service\DS18B20; Service\IO; Service\Dimmer; Service\DHT21; Service\TdsSensor; Service\JSN-SR04T; Service\Lcd_1602; Service\Delay; Service\StepMotor; Service\Buzz; Service\BlinkLed; Hardware\ADC; Hardware\Flash; Hardware\ADC; Hardware\PWM; Hardware\System; Hardware\Uart; Hardware\IO; Hardware\HardWareTimer; Hardware\Flash
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Platform.hex
  ILINK.IlinkOutputFile: Platform.out
  ILINK.IlinkIcfFile: stm32f100_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Image (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; RELEASE
  ICCARM.PreInclude: Application\Main\types.h
  ICCARM.CCIncludePath2: Application\Main; Libraries\STM32F10x_StdPeriph_Driver\inc\; Libraries\CMSIS\CM3\ST\STM32F10x; Libraries\CMSIS\CM3\CoreSupport; Service; Service\Timer; Service\Parameters; Service\Device; Hardware\ADC; Hardware\Flash; Hardware\System; Hardware\Uart
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Platform.bin
  ILINK.IlinkIcfFile: Z.ICF\stm32f100_flash_direct.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Direct (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; RELEASE
  ICCARM.PreInclude: Application\Main\types.h
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkKeepSymbols: SYMBOOT
  ILINK.IlinkIcfFile: Z.ICF\stm32f100_flash_direct.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    Application/Main/: main.c Params.h
  group hardware/adc
    Hardware/ADC/: adc.c adc.h
  group hardware/flash
    Hardware/Flash/: flash.c flash.h
  group hardware/HardWareTimer
    Hardware/HardWareTimer/: hw_timer.c hw_timer.h
  group hardware/io
    Hardware/IO/: io.c io.h
  group hardware/pwm
    Hardware/PWM/: pwm.c pwm.h
  group hardware/system
    Hardware/System/: system.c system.h
  group hardware/uart
    Hardware/Uart/: uart.c uart.h
  group libraries/cmsis
    Libraries/CMSIS/: core_cm3.c core_cm3.h
  group libraries/peripheral/inc
    Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group libraries/peripheral/src
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group libraries/startup
    Libraries/Startup/: startup_stm32f10x_md.s
  group libraries/systemconfig
    Libraries/Systemconfig/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group services/BlinkLed
    Service/BlinkLed/: blinkled.c blinkled.h
  group services/Buzz
    Service/Buzz/: buzz.c buzz.h
  group services/Delay
    Service/Delay/: user_delay.c user_delay.h
  group services/device
    Service/Device/: device.c device.h
  group services/dimmer
    Service/Dimmer/: dimmer.c dimmer.h
  group services/ds18b20
    Service/DS18B20/: ds18b20.c ds18b20.h
  group services/JSN-SR04T
    Service/JSN-SR04T/: JSNSensor.c JSNSensor.h
  group services/LCD_1602
    Service/Lcd_1602/: lcd16x2.c lcd16x2.h
  group services/parameter
    Service/Parameters/: parameter.c parameter.h
  group services/service_io
    Service/IO/: service_io.c service_io.h
  group services/StepMotor
    Service/StepMotor/: stepmotor.c stepmotor.h
  group services/timer
    Service/Timer/: timer.c timer.h
