# Keil uVision project WAV_Player_MiniSTM32.uvproj, settings and files
target WAV_Player_MiniSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WAV_Player_MiniSTM32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Mini_STM32;.\Petit_FAT;.\WAV_Player;.\ST\CMSIS\CM3\CoreSupport;.\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\ST\STM32F10x_StdPeriph_Driver\inc;.\FFT;.\CoOS\kernel;.\CoOS\portable
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group WAV_Player
    ./WAV_Player/: main.c pwm_audio.c stm32f10x_it.c wave_file.c
  group Petit_FAT
    ./Petit_FAT/: pff.c sd_mmc.c
  group CoOS
    ./CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c queue.c sem.c serviceReq.c task.c time.c timer.c utility.c
    ./CoOS/portable/: arch.c port.c
  group FFT
    ./FFT/: Ek_FFT128Real_32b.s Ek_Magnitude.s Ek_Window16to32b_real.s
  group Mini_STM32
    ./Mini_STM32/: ministm32_lcd.c ministm32_pwm.c ministm32_spi.c ministm32_led.c ministm32_pb.c
  group STM32_FWLib
    ./ST/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./ST/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./ST/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/: startup_stm32f10x_md.s
    ./ST/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
